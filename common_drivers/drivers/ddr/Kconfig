## common_drivers/drivers/ddr/Kconfig
```kconfig
config DDR_SSC_TUNING
	bool "enable to support tuning SSC in factory menu"
	default y
```
